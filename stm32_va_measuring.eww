<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\App\va_measure_app.ewp</path>
    </project>
    <batchBuild />
</workspace>
